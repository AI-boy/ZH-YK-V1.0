# Keil uVision project ZH-YK.uvproj, settings and files
target ZH-YK-001 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ZH-YK +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;C:\Keil\C51\INC\STC
  group Source Files
    ../src/: beep.c delay.c interrupt.c ird_remote.c key.c lcd12864.c led.c main.c Modbus.c pwm.c timer.c uart.c io.c
  group Header Files
    ../include/: beep.h delay.h interrupt.h ird_remote.h key.h lcd12864.h led.h Modbus.h pwm.h timer.h uart.h userdefine.h io.h
